# Keil uVision project MAXREFDES61.uvproj, settings and files
target MAXREFDES61 Configuration (ARM-ADS)
  device: STM32F415RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: MAXREFDES61 Configuration
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F415xx,
  c misc: --C99
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Inc; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Drivers\CMSIS\Include
  asm include: ..\..\Inc;..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: MAXREFDES61 Configuration\MAXREFDES61 Configuration.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f415xx.s
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Application/User
    ../../Src/: gpio.c i2c.c main.c spi.c stm32f4xx_it.c tim.c usart.c maximDeviceSpecificUtilities.c menu.c retarget.c utilities.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
